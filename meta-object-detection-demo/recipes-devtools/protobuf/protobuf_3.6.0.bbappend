SRC_URI_remove = "git://github.com/google/protobuf.git;branch=3.6.x"
SRC_URI_append = " git://github.com/google/protobuf.git;protocol=https;branch=3.6.x"
