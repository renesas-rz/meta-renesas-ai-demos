SRC_URI_remove = "git://github.com/renesas-rcar/gst-plugins-bad.git;branch=RCAR-GEN3/1.12.2;name=base"
SRC_URI_prepend = "git://github.com/renesas-rcar/gst-plugins-bad.git;protocol=https;branch=RCAR-GEN3/1.12.2;name=base "
