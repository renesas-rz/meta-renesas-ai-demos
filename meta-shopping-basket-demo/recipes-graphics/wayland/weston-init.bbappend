include weston-shopping-demo.inc
