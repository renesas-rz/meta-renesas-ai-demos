include weston-ai-demos.inc
